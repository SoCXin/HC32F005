# Keil uVision project template.uvprojx, settings and files
target template_Release (6160000::V6.16::ARMCLANG)
  device: HC32F003C4PA HDSC
  pack: HDSC.HC32F003.1.0.1
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  AfterMake: fromelf --bin "$L@L.axf" --output "$L@L.bin"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\..\custom
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f003.s
    ../../mcu/common/: system_hc32f003.c
  group source
    ../source/: main.c
  group driver
    ../../driver/src/: ddl.c interrupts_hc32f003.c clk.c gpio.c uart.c adc.c bt.c wdt.c
  group custom
    ../../custom/bsp_hw_mcu/: bsp_usart.c bsp_adc.c bsp_iwdg.c bsp_clk.c bsp_gpio.c bsp_mcu_id.c
    ../../custom/api_uart_protocol/: api_uart_protocol.c
    ../../custom/shared_power_handler/: api_shared_pwr_handler.c
    ../../custom/bsp_check/: bsp_check_dev.c
    ../../custom/systick/: api_sys_timer.c
    ../../custom/bsp_charge/: bsp_batterymanage.c
software components: CMSIS:CORE 5.4.0
