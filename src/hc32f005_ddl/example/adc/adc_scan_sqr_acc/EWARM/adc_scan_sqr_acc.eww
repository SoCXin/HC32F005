<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adc_scan_sqr_acc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


