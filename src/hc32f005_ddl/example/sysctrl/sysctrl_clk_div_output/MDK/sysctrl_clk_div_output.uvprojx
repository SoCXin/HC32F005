# Keil uVision project sysctrl_clk_div_output.uvprojx, settings and files
target sysctrl_clk_div_output_Release (6100001::V6.10.1::.\ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ESEL ELITTLE
  output: sysctrl_clk_div_output +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../../mcu/common/: system_hc32f005.c interrupts_hc32f005.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c sysctrl.c gpio.c flash.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
